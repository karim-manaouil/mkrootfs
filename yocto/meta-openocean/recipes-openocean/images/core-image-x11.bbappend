IMAGE_INSTALL += "packagegroup-lxde-base"
